# Keil uVision project usart_test.uvproj, settings and files
target Gpio (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: gpio +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\MainFile;..\stdPeriphDriveLib\inc;..\HardWare
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group ARM
    ../ARM/: startup_stm32f10x_hd.s
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c stm32f10x.h
  group MainFile
    ../MainFile/: main.c stm32f10x_it.c stm32f10x_it.h stm32f10x_conf.h
  group stdPeriphDriveLib
    ../stdPeriphDriveLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c delay.c
  group HardWare
    ../HardWare/: UART.c UART.h
